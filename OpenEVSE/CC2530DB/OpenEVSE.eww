<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\OpenEVSE.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>OpenEVSE</project>
        <configuration>RouterEB</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


